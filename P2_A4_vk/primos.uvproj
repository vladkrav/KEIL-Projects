# Keil uVision project primos.uvproj, settings and files
target Primos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: primos
  group Inicializacion
    ./: startup_LPC17xx.s startup_ARMCM3.S
  group Configuracion
    ./: system_LPC17xx.c
  group main
    ./: primos.c
